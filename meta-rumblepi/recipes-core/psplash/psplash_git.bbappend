FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://psplash-rumblepi-img.h;outsuffix=rumblepi"
