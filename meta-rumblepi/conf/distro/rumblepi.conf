## meta-rumblepi/conf/distro/rumblepi.conf
```bitbake
DISTRO = "rumblepi"
DISTRO_NAME = "Rumble PI (Custom OS for Raspberry PI)"
DISTRO_VERSION = "0.1"
DISTRO_CODENAME = "dev"
```
